# Stub class for OE-Alliance Enigma2 plugin builds
# Neutrino builds don't use Enigma2 plugins, so this class is empty
# This prevents parse errors when OE-Alliance recipes try to inherit this class

# Empty class - does nothing
