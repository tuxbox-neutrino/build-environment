# Fix obsolete LICENSE identifier (upstream already uses SPDX format)

PR:append = ".1"

LICENSE = "LGPL-2.1-or-later"
