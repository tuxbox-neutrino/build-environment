PR:append = ".1"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0001-add-lock-obj-pub-for-arm-unknown-linux-uclibcgnueabi.patch"
