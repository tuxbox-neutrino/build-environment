# Stub class to satisfy enigma2 openplugins recipes when masked or unused.
# We do not build Enigma2, but OA recipes may still parse; keep this empty.
