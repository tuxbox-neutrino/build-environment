# Use the upstream krb5 recipe from poky/meta. Legacy krb5_1.16.1 from
# meta-neutrino/recipes-local is masked in layer.conf to avoid clashes.
# Add customisations here if needed.
