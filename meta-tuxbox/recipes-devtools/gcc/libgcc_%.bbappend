# Align sstate/package arch with OE-Alliance machine-specific naming
PACKAGE_ARCH = "${MACHINE_ARCH}"
SSTATE_PKGARCH = "${MACHINE_ARCH}"
