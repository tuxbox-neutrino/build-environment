PV = "0.4.5"

SRC_URI[md5sum] = "025b19744e5c7fc1c8380e17df1fcc64"
SRC_URI[sha256sum] = "528635e674addea5c2b3a3268404ad04a952c4f410d17c3d754f5dd5529770c9"
