# Ensure native builds can import Jinja2 (requires MarkupSafe).
DEPENDS:append:class-native = " python3-markupsafe-native"
