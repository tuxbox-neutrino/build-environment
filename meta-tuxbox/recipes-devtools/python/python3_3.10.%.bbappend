# Drop OE-Alliance importlib patch that no longer applies cleanly
SRC_URI:remove = "file://importlib.patch"
