FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://sysctl.conf"

