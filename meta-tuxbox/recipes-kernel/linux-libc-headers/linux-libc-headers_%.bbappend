# Ensure sstate manifests match OE-Alliance machine-specific arch naming
PACKAGE_ARCH = "${MACHINE_ARCH}"
SSTATE_PKGARCH = "${MACHINE_ARCH}"
