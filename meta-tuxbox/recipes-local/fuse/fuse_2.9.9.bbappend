FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://closefrom-rename.patch"
