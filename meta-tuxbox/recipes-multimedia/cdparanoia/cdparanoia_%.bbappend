FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://format-security.patch"
