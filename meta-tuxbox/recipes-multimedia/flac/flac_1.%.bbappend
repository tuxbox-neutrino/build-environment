DEPENDS:append = " virtual/libiconv"


