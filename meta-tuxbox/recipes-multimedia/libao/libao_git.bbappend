PR:append = ".1"

# Pin SRCREV to avoid AUTOREV network lookups during parsing.
SRCREV = "cafce902a73c1050474a62feff83e428bbbee5f4"
