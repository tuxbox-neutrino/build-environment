FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://format-security.patch"
