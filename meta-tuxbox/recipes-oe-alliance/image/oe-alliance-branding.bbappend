# Remove missing upstream patch to keep parsing clean
SRC_URI:remove = "file://ax-python-devel-dont-check-for-distutils.patch"
